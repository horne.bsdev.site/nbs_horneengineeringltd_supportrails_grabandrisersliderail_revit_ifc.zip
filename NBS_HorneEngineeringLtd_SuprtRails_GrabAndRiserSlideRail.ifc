Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-11T08:09:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220517_1515(x64) - Exporter 20.2.90.12 - Alternate UI 20.2.90.12
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 11 08:09:46 2023 * Host: BIMServices * Database: C:\Users\PIOTRB~1\AppData\Local\Temp\f417ea85-6b6b-487b-86c9-a28277fa1a04\acbd3448-1399-4e1e-b067-3cbce7652a63\ifc * Database version: 5507 * Database creation date: Wed Oct 11 08:09:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 11 08:09:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 11 08:09:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcFurnishingElement: GrabRailWhiteGrey706611, NBS_HorneEngineeringLtd_SuprtRails_GrabAndRiserSlideRail:GrabRailWhiteGrey706611:378771
In: Level 0
Type - Material: NBS_HorneEngineeringLtd_Grey, NBS_HorneEngineeringLtd_White
Type - BOS_General - Author: NBS; BIMObjectName: NBS_HorneEngineeringLtd_SupportRails_GrabAndRiserSlideRail_GrabRailWhiteGrey706611; ManufacturerName: Horne Engineering Ltd; ManufacturerURL: www.horne.co.uk; ProductInformation: https://source.thenbs.com/product/-/c34bff4a-1def-4c56-b00d-ffe8fe9d91f9/dd501b2b-a10c-4d38-a1f6-c3737aa839af; Uniclass2015Title: Support rails; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Version: Products v1.31; Version: 1
Type - NBS_Data - CountryOfProductManufacture: United Kingdom; Diameter: 32 mm; Fixing: Fixing centres 675 mm; Form: Fixed; IntegralAccessories: n/a; MaterialsBody: Aluminium; MaterialsFinishAndColour: Powder-coated, white (RAL 9010)
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_76_84:Support rails; CodePerformance: n/a; Color: White,Orange,Grey; Constituents: n/a; Description: Polyester powder-coated anodized aluminium grab or handrails with fixing plate; DurationUnit: year; ExpectedLife: n/a; Features: Robust polyester powder-coated anodized aluminium, 675 mm long between fixing point centres; Finish: Powder-coated; Grade: n/a; Manufacturer: specifications@horne.co.uk; Material: Aluminium,Plastic; ModelNumber: 70-6611; ModelReference: Wall Mounted Support Rails; Name: SupportRails_GrabAndRiserSlideRail_GrabRailWhiteGrey706611_HorneEngineeringLtd; NominalHeight: 0 mm; NominalLength: 675 mm; NominalWidth: 32 mm; ReplacementCost: n/a; Shape: Other; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Two year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
